SUMMARY = "WIIPIIDO Gateway application"
DESCRIPTION = "Installs Gateway application and dependencies"
LICENSE = "CLOSED"

COMPATIBLE_MACHINE = "wiipiido"

DEPENDS = "nodejs"

do_configure() {
}

do_compile() {
}

do_install() {
}
